FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:append:tegra = " file://0001-lttng-tracepoint-discard-warning-message-on-NVDA-pla.patch"
