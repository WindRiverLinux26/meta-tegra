FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Fix-HIGHP_OR_DEFAULT-macro-redefined-error-on-NVIDIA.patch"
